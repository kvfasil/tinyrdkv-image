SUMMARY = " To add oem or SOC specific packages as part of core-image-minimal build"

require ${RDKROOT}/meta-amlogic/recipes-core/images/aml-package.inc
